# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;applications;drivers;.\ESC32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
    ./applications/: db_can_message.h cpuusage.c thread_can.c
  group Drivers
    drivers/: board.c stm32f10x_it.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group ESC32
    ./ESC32/: adc.c binary.c cli.c config.c digital.c fet.c getbuildnum.c ow.c pwm.c rcc.c run.c serial.c main.c timer_esc.c
